options:
  parameters:
    generate_options: qt_gui
    id: FM_Broadcast
    output_language: python
  states: {}

blocks:
- name: FM_freq
  id: variable_qtgui_range
  parameters:
    start: 105e6
    step: 0.1e6
    stop: 110e6
    value: 105e6
  states: {}
- name: audio_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '2'
    value: '0.7'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '2'
    stop: '62'
    value: '0'
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '8'
    stop: '40'
    value: '0'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '12'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: audio_rate * 40
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: 'audio_rate '
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: audio_rate * 2
    tau: '75e-6'
  states: {state: disabled}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: 'audio_rate '
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: audio_rate * 4
    tau: '75e-6'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: test.wav
    repeat: 'True'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: ''
    bb_gain0: bb_gain
    freq0: FM_freq
    gain0: rf_gain
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    label1: ''
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: FM_freq
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(samp_rate / audio_rate / 4)
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(samp_rate / audio_rate / 2)
    taps: ''
    type: ccc
  states: {state: disabled}

connections:
- [analog_nbfm_tx_0, '0', rational_resampler_xxx_0_0_0, '0']
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', analog_nbfm_tx_0, '0']
- [blocks_multiply_const_vxx_0, '0', analog_wfm_tx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_complex_to_mag_0, '0']
- [rational_resampler_xxx_0_0, '0', osmosdr_sink_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_0_0_0, '0', blocks_complex_to_mag_0, '0']
- [rational_resampler_xxx_0_0_0, '0', osmosdr_sink_0, '0']
- [rational_resampler_xxx_0_0_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
